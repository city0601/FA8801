# Keil uVision project peripherals_app.uvprojx, settings and files
target peripherals_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM4_FP_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: peripherals_app +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output FITI_M4.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o FITI_M4.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARMCM4_FP
  c include: ..\APP;..\CORE;..\PERIPHERALS\Includes;..\SYSTEM;..\USER;..\CMSIS\DSP\inc;..\CMSIS\DSP\inc\dsp;..\CMSIS\DSP\inc\PrivateInclude;..\CMSIS\NN\inc;..\APP\Peripherals Application;..\MIDDLEWARE\Inludes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group CORE
    ../CORE/: core_cm4.c
  group STARTUP
    ../STARTUP/: startup_FITI_CM4.s
  group SYSTEM
    ../SYSTEM/: system_FITI_M4.c
  group PERIPHERALS
    ../PERIPHERALS/Sources/: FITI_M4_ddr3.c FITI_M4_ethernet.c FITI_M4_gpio.c FITI_M4_i2c.c FITI_M4_misc.c FITI_M4_rtc.c FITI_M4_spi.c FITI_M4_spi_flash.c FITI_M4_timer.c FITI_M4_uart.c FITI_M4_wdog.c Fiti_System_I2c.c
  group APP
    ../APP/: app.c
  group USER
    ../USER/: main.c app_if.c malloc.c retarget.c FITI_M4_it.c
  group CMSIS_DSP
    ../CMSIS/DSP/src/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../CMSIS/DSP/src/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../CMSIS/DSP/src/CommonTables/: CommonTables.c CommonTablesF16.c
    ../CMSIS/DSP/src/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../CMSIS/DSP/src/ControllerFunctions/: ControllerFunctions.c
    ../CMSIS/DSP/src/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../CMSIS/DSP/src/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../CMSIS/DSP/src/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../CMSIS/DSP/src/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../CMSIS/DSP/src/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../CMSIS/DSP/src/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../CMSIS/DSP/src/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../CMSIS/DSP/src/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../CMSIS/DSP/src/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../CMSIS/DSP/src/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group CMSIS_NN
    ../CMSIS/NN/src/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ../CMSIS/NN/src/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_add_s16.c arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c
    ../CMSIS/NN/src/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ../CMSIS/NN/src/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s16.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
    ../CMSIS/NN/src/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c arm_fully_connected_s16.c
    ../CMSIS/NN/src/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ../CMSIS/NN/src/PoolingFunctions/: arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_max_pool_s16.c arm_pool_q7_HWC.c
    ../CMSIS/NN/src/ReshapeFunctions/: arm_reshape_s8.c
    ../CMSIS/NN/src/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ../CMSIS/NN/src/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group MIDDLEWARE
    ../MIDDLEWARE/Sources/: Fiti_System_I2c_Middleware.c
software components: CMSIS:CORE 5.6.0
